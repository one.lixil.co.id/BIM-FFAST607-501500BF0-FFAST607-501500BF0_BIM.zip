Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-03-30T09:19:28
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.60.25 - Exporter 21.1.60.25 - Alternate UI 21.1.60.25
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Mar 30 09:19:28 2023 * Host: CHATPONG-DEE * Database: C:\Users\CHATPONG\AppData\Local\Temp\b31d0abb-89fe-454c-af08-ee0ea68c0ad2\43d2f92c-0a72-44b6-8406-8fa4ec619e0d\ifc * Database version: 5507 * Database creation date: Thu Mar 30 09:19:28 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Mar 30 09:19:28 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Mar 30 09:19:28 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcDistributionPort, Port_357351
Description: Flow; FlowDirection: SOURCE

# IfcFlowTerminal: FFAST607-501500BF0_REVIT:Winston Wall Mounted Kitchen Mono(Lever Handle), FFAST607-501500BF0_REVIT:Winston Wall Mounted Kitchen Mono(Lever Handle):357351
In: Level 1
Type - Material: <Unnamed>, Chrome
Type - Pset_ManufacturerTypeInformation - Manufacturer: American Standard
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Type - Pset_QuantityTakeOff - Reference: Winston Wall Mounted Kitchen Mono(Lever Handle)
Material: Chrome
Pset_DistributionFlowElementCommon - Reference: Winston Wall Mounted Kitchen Mono(Lever Handle); sets with these values: 2
